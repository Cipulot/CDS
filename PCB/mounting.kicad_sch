File: PCB/mounting.kicad_sch (KiCad schematic)
At the start: 49 parts

Commit message: Updated sheets
Other:
- company: Cipulot PCB Design  -> LU.SV Solutions
- title: CDS - Mounting Points -> CDS
